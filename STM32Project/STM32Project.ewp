# IAR project STM32Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F050x4 ST STM32F050x4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_FULL_ASSERT; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; Libraries\CMSIS\Include; Libraries\CMSIS\ST\STM32F0xx\Include; Libraries\STM32F0xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32Project.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: STM32Project.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: common.h Kernel.c Kernel.h LedManager.c LedManager.h main.c stm32f0xx_conf.h stm32f0xx_it.c stm32f0xx_it.h task_manager.c task_manager.h
  group CMSIS
    Libraries/CMSIS/Include/: arm_common_tables.h arm_math.h core_cm0.h core_cmFunc.h core_cmInstr.h
    Libraries/CMSIS/ST/STM32F0xx/Include/: stm32f0xx.h system_stm32f0xx.h
  group StdPeriph
    Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
    Libraries/STM32F0xx_StdPeriph_Driver/inc/: stm32f0xx_adc.h stm32f0xx_cec.h stm32f0xx_comp.h stm32f0xx_crc.h stm32f0xx_dac.h stm32f0xx_dbgmcu.h stm32f0xx_dma.h stm32f0xx_exti.h stm32f0xx_flash.h stm32f0xx_gpio.h stm32f0xx_i2c.h stm32f0xx_iwdg.h stm32f0xx_misc.h stm32f0xx_pwr.h stm32f0xx_rcc.h stm32f0xx_rtc.h stm32f0xx_spi.h stm32f0xx_syscfg.h stm32f0xx_tim.h stm32f0xx_usart.h stm32f0xx_wwdg.h
